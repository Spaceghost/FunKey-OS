## FunKey/package/bibi/Config.in
```kconfig
config BR2_PACKAGE_BIBI
	bool "FunKey S - bibi"
	help
	  Bomberman game in c with SDL, readapted for the FunKey S.
```
